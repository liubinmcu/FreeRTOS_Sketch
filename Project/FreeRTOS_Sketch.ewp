# IAR project FreeRTOS_Sketch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Application; ..\CMSIS; ..\Driver; ..\FWLib\inc; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Application; ..\FreeRTOS\portable\IAR\ARM_CM4F
  ILINK.IlinkOutputFile: FreeRTOS_Sketch.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../Application/: app_task_create.c app_task_eventgroup.c app_task_main.c app_task_queue.c app_task_semphr.c app_task_softwaretimer.c app_task_statistics.c FreeRTOSConfig.h main.c stm32f4xx_it.c
  group CMSIS
    ../CMSIS/: startup_stm32f411xe.s system_stm32f4xx.c
  group Driver
    ../Driver/: bsp_drv_timer.c bsp_hardware.c
  group FreeRTOS/Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FWLib
    ../FWLib/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
